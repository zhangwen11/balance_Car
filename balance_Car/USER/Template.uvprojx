# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Public\led;..\Public\timer;..\Public\motor;..\Public\IIC;..\Public\key;..\Public\encoder;..\Public\exti;..\Public\oled;..\Public\usart3;..\DMP;..\Public\MPU6050;..\Public\show;..\Public\control;..\Public\filter;..\Public\adc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group Public
    ../Public/led/: led.c
    ../Public/timer/: timer.c
    ../Public/motor/: motor.c
    ../Public/encoder/: encoder.c
    ../Public/IIC/: IOI2C.c
    ../Public/key/: key.c
    ../Public/exti/: exti.c
    ../Public/oled/: oled.c
    ../Public/usart3/: usart3.c
    ../Public/MPU6050/: MPU6050.c
    ../Public/adc/: adc.c
    ../Public/show/: show.c
    ../Public/control/: control.c
    ../Public/filter/: filter.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DMP
    ../DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group README
    ../: README.TXT
